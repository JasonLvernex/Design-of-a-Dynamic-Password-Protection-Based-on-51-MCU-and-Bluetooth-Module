# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dtmms_bt_essay +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: lcd.c main.c key.c i2c.c timer.c timer.h codemm.c codemm.h bluetoothmm.c bluetoothmm.h
